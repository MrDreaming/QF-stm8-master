# IAR project QF-stm8-master.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\user; ..\drive
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: QF-stm8-master.srec
  ILINK.IlinkOutputFile: QF-stm8-master.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group drive
    ../drive/: led.c tim1.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_uart1.c
    ../drive/: stm8s_interruput.c
  group user
    ./: main.c queue.c server.c
